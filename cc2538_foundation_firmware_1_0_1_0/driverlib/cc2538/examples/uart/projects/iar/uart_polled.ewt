<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>driverlib</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\source\adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\source\cpu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\source\debug.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\source\flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\source\gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\source\gptimer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\source\i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\source\interrupt.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\source\ioc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\source\sleepmode.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\source\ssi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\source\sys_ctrl.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\source\systick.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\source\uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\source\udma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\source\watchdog.c</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\..\..\..\startup_files\startup_iar.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\source\uart_polled.c</name>
  </file>
</project>


