<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>application</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\startup_files\startup_iar.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\source\uart_example.c</name>
    </file>
  </group>
  <group>
    <name>bsp</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\drivers\source\bsp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\drivers\source\bsp.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\drivers\source\bsp_key.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\drivers\source\bsp_led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\drivers\source\bsp_uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\drivers\source\io_pin_int.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\drivers\source\lcd_dogm128_6.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\drivers\source\lcd_dogm128_6_alphabet.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\drivers\source\lcd_srf06eb.c</name>
    </file>
  </group>
  <group>
    <name>driverlib</name>
    <group>
      <name>headers</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\source\adc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\source\cpu.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\source\debug.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\source\flash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\source\gpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\source\gptimer.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\source\i2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\source\interrupt.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\source\ioc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\source\sleepmode.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\source\ssi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\source\sys_ctrl.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\source\systick.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\source\uart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\source\udma.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\source\watchdog.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\source\adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\source\cpu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\source\debug.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\source\flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\source\gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\source\gptimer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\source\i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\source\interrupt.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\source\ioc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\source\sleepmode.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\source\ssi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\source\sys_ctrl.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\source\systick.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\source\uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\source\udma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\source\watchdog.c</name>
    </file>
  </group>
  <group>
    <name>inc</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\inc\hw_aes.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\inc\hw_ana_regs.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\inc\hw_flash_ctrl.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\inc\hw_gpio.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\inc\hw_gptimer.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\inc\hw_i2cm.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\inc\hw_i2cs.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\inc\hw_ints.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\inc\hw_ioc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\inc\hw_memmap.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\inc\hw_nvic.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\inc\hw_pka.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\inc\hw_rfcore_ffsm.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\inc\hw_rfcore_sfr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\inc\hw_rfcore_xreg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\inc\hw_smwdthrosc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\inc\hw_soc_adc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\inc\hw_ssi.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\inc\hw_sys_ctrl.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\inc\hw_types.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\inc\hw_uart.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\inc\hw_udma.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\inc\hw_udmachctl.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\cc2538\inc\hw_usb.h</name>
    </file>
  </group>
</project>


