<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>source</name>
    <group>
      <name>cc2538</name>
      <file>
        <name>$PROJ_DIR$\..\..\source\library\cc2538\usb.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\source\library\cc2538\usb.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\source\library\cc2538\usb_firmware_library_headers.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\source\library\cc2538\usb_interrupt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\source\library\cc2538\usb_suspend.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\source\library\hw_usb_aliases.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\source\library\usb_descriptor_defs.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\source\library\usb_descriptor_parser.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\source\library\usb_descriptor_parser.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\source\library\usb_framework.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\source\library\usb_framework.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\source\library\usb_in_buffer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\source\library\usb_in_buffer.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\source\library\usb_interrupt.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\source\library\usb_out_buffer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\source\library\usb_out_buffer.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\source\library\usb_standard_requests.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\source\library\usb_standard_requests.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\source\library\usb_suspend.h</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\usblib_iar.cfg</name>
  </file>
</project>


